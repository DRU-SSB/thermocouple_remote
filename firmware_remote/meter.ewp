# IAR project meter.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8l15x.h
